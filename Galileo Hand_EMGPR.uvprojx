# Keil uVision project Galileo Hand_EMGPR.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK20DX256xxx7 NXP
  pack: Keil.Kinetis_K20_DFP.1.7.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00040000) IROM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Galileo Hand_EMGPR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  group Source Group 1
    ./: drivers.c finger.c main.c drivers.h finger.h
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:Startup 1.0.0
